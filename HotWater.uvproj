# Keil uVision project HotWater.uvproj, settings and files
target STC15W4KXX (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: HotWater +hex
  c flags: Optimize=9 SizeSpeed=1
  group Boot
    ./: STARTUP.A51
  group 热水器
    ./: HOTWATER_51.C hotwater_51.h
